# Keil uVision project Project.uvproj, settings and files
target STM32F107VC (ARM-ADS)
  device: STM32F103RE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Project +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c misc: --C99
  c include: .\Library;.\Library\STM32F10x_StdPeriph_Driver\inc;.\Library\GUI;.\Library\GUI\incgui;.\Library\ARM-radio-master\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group MDK-ARM startup
    ./: startup_stm32f10x_hd.s
  group CMSIS
    ./Library/: core_cm3.c system_stm32f10x.c
  group StdPeriph Driver
    ./Library/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_spi.c
  group User
    ./Library/: main.c stm32f10x_it.c
  group GUI
    ./Library/GUI/: GUI_CM3.lib GUI_X.c GUI_X_Touch.c GUIConf.c LCD_X_Config.c LCDConf.c ads7843.c GUI_X_Touch_Analog.c
